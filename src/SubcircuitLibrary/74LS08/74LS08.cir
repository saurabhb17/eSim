* /home/ash98/Downloads/eSim-1.1.3/src/SubcircuitLibrary/74LS08/74LS08.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Tue Jan 14 16:54:57 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad10_ Net-_U1-Pad9_ Net-_U1-Pad13_ Net-_U1-Pad12_ Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U3-Pad11_ Net-_U3-Pad12_ Net-_U3-Pad13_ Net-_U3-Pad14_ Net-_U3-Pad15_ Net-_U3-Pad16_ adc_bridge_8
U5  Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U2-Pad1_ d_and
U6  Net-_U3-Pad11_ Net-_U3-Pad12_ Net-_U4-Pad1_ d_and
U7  Net-_U3-Pad13_ Net-_U3-Pad14_ Net-_U7-Pad3_ d_and
U8  Net-_U3-Pad15_ Net-_U3-Pad16_ Net-_U10-Pad1_ d_and
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ Net-_U10-Pad2_ Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_R3-Pad1_ Net-_R4-Pad1_ dac_bridge_4
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_Q1-Pad1_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q3-Pad1_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_Q4-Pad1_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_R5-Pad1_ PORT
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 1k
U2  Net-_U2-Pad1_ Net-_U13-Pad1_ d_inverter
U9  Net-_U7-Pad3_ Net-_U13-Pad3_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U4  Net-_U4-Pad1_ Net-_U13-Pad2_ d_inverter
R5  Net-_R5-Pad1_ Net-_Q1-Pad1_ 100
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_R2-Pad1_ Net-_Q2-Pad2_ 1k
R6  Net-_R5-Pad1_ Net-_Q2-Pad1_ 100
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_R3-Pad1_ Net-_Q3-Pad2_ 1k
R7  Net-_R5-Pad1_ Net-_Q3-Pad1_ 100
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R4  Net-_R4-Pad1_ Net-_Q4-Pad2_ 1k
R8  Net-_R5-Pad1_ Net-_Q4-Pad1_ 100

.end
