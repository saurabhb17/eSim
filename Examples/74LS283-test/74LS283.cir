* /home/sysad/Downloads/eSim-1.1.3/src/SubcircuitLibrary/74LS283/74LS283.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Wed Jan 22 16:57:33 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X4  Net-_U6-Pad9_ Net-_U6-Pad13_ Net-_U8-Pad2_ Net-_U9-Pad1_ Net-_X3-Pad3_ full_adder
X3  Net-_U6-Pad10_ Net-_U6-Pad14_ Net-_X3-Pad3_ Net-_U7-Pad1_ Net-_X2-Pad3_ full_adder
X2  Net-_U6-Pad11_ Net-_U6-Pad15_ Net-_X2-Pad3_ Net-_U4-Pad1_ Net-_X1-Pad3_ full_adder
X1  Net-_U6-Pad12_ Net-_U6-Pad16_ Net-_X1-Pad3_ Net-_U3-Pad1_ Net-_U2-Pad1_ full_adder
U6  Net-_U1-Pad5_ Net-_U1-Pad3_ Net-_U1-Pad14_ Net-_U1-Pad12_ Net-_U1-Pad6_ Net-_U1-Pad2_ Net-_U1-Pad15_ Net-_U1-Pad11_ Net-_U6-Pad9_ Net-_U6-Pad10_ Net-_U6-Pad11_ Net-_U6-Pad12_ Net-_U6-Pad13_ Net-_U6-Pad14_ Net-_U6-Pad15_ Net-_U6-Pad16_ adc_bridge_8
U8  Net-_U1-Pad7_ Net-_U8-Pad2_ adc_bridge_1
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ Net-_U4-Pad2_ Net-_U3-Pad2_ Net-_U2-Pad2_ Net-_R9-Pad1_ Net-_R7-Pad1_ Net-_R5-Pad1_ Net-_R3-Pad1_ Net-_R1-Pad1_ dac_bridge_5
U9  Net-_U9-Pad1_ Net-_U5-Pad1_ d_inverter
U7  Net-_U7-Pad1_ Net-_U5-Pad2_ d_inverter
U4  Net-_U4-Pad1_ Net-_U4-Pad2_ d_inverter
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ d_inverter
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R9  Net-_R9-Pad1_ Net-_Q5-Pad2_ 1k
R10  Net-_R10-Pad1_ Net-_Q5-Pad1_ 100
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R7  Net-_R7-Pad1_ Net-_Q4-Pad2_ 1k
R8  Net-_R10-Pad1_ Net-_Q4-Pad1_ 100
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R5  Net-_R5-Pad1_ Net-_Q3-Pad2_ 1k
R6  Net-_R10-Pad1_ Net-_Q3-Pad1_ 100
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_R3-Pad1_ Net-_Q2-Pad2_ 1k
R4  Net-_R10-Pad1_ Net-_Q2-Pad1_ 100
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 1k
R2  Net-_R10-Pad1_ Net-_Q1-Pad1_ 100
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ d_inverter
U1  Net-_Q4-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_Q5-Pad1_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_Q1-Pad3_ Net-_Q1-Pad1_ Net-_Q2-Pad1_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_Q3-Pad1_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_R10-Pad1_ PORT
R15  Net-_Q5-Pad1_ Net-_Q1-Pad3_ 100k
R14  Net-_Q4-Pad1_ Net-_Q1-Pad3_ 100k
R13  Net-_Q3-Pad1_ Net-_Q1-Pad3_ 100k
R12  Net-_Q2-Pad1_ Net-_Q1-Pad3_ 100k
R11  Net-_Q1-Pad1_ Net-_Q1-Pad3_ 100k

.end
