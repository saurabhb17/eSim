* /home/ash98/Downloads/eSim-1.1.3/src/SubcircuitLibrary/74LS175/74LS175.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Thu Jan 16 10:29:59 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_U3-Pad1_ Net-_U2-Pad2_ ? Net-_U1-Pad2_ Net-_U3-Pad5_ Net-_U3-Pad6_ d_dff
U4  Net-_U4-Pad1_ Net-_U2-Pad2_ ? Net-_U1-Pad2_ Net-_U4-Pad5_ Net-_U4-Pad6_ d_dff
U6  Net-_U6-Pad1_ Net-_U2-Pad2_ ? Net-_U1-Pad2_ Net-_U5-Pad3_ Net-_U5-Pad4_ d_dff
U8  Net-_U7-Pad7_ Net-_U2-Pad2_ ? Net-_U1-Pad2_ Net-_U5-Pad1_ Net-_U5-Pad2_ d_dff
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ d_buffer
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ d_inverter
U7  Net-_U7-Pad1_ Net-_U7-Pad2_ Net-_U7-Pad3_ Net-_U7-Pad4_ Net-_U7-Pad5_ Net-_U7-Pad6_ Net-_U7-Pad7_ Net-_U6-Pad1_ Net-_U4-Pad1_ Net-_U3-Pad1_ Net-_U2-Pad1_ Net-_U1-Pad1_ adc_bridge_6
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ Net-_U5-Pad3_ Net-_U5-Pad4_ Net-_U4-Pad5_ Net-_U4-Pad6_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_R15-Pad1_ Net-_R13-Pad1_ Net-_R11-Pad1_ Net-_R9-Pad1_ Net-_R7-Pad1_ Net-_R5-Pad1_ Net-_R3-Pad1_ Net-_R1-Pad1_ dac_bridge_8
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 1k
R2  Net-_R10-Pad1_ Net-_Q1-Pad1_ 100
U9  Net-_U7-Pad6_ Net-_Q7-Pad1_ Net-_Q8-Pad1_ Net-_U7-Pad1_ Net-_U7-Pad2_ Net-_Q6-Pad1_ Net-_Q5-Pad1_ Net-_Q1-Pad3_ Net-_U7-Pad5_ Net-_Q3-Pad1_ Net-_Q4-Pad1_ Net-_U7-Pad3_ Net-_U7-Pad4_ Net-_Q2-Pad1_ Net-_Q1-Pad1_ Net-_R10-Pad1_ PORT
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_R3-Pad1_ Net-_Q2-Pad2_ 1k
R4  Net-_R10-Pad1_ Net-_Q2-Pad1_ 100
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R5  Net-_R5-Pad1_ Net-_Q3-Pad2_ 1k
R6  Net-_R10-Pad1_ Net-_Q3-Pad1_ 100
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R7  Net-_R7-Pad1_ Net-_Q4-Pad2_ 1k
R8  Net-_R10-Pad1_ Net-_Q4-Pad1_ 100
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R9  Net-_R9-Pad1_ Net-_Q5-Pad2_ 1k
R10  Net-_R10-Pad1_ Net-_Q5-Pad1_ 100
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R11  Net-_R11-Pad1_ Net-_Q6-Pad2_ 1k
R12  Net-_R10-Pad1_ Net-_Q6-Pad1_ 100
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R13  Net-_R13-Pad1_ Net-_Q7-Pad2_ 1k
R14  Net-_R10-Pad1_ Net-_Q7-Pad1_ 100
Q8  Net-_Q8-Pad1_ Net-_Q8-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R15  Net-_R15-Pad1_ Net-_Q8-Pad2_ 1k
R16  Net-_R10-Pad1_ Net-_Q8-Pad1_ 100

.end
