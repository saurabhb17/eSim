* /home/ash98/Downloads/eSim-1.1.3/src/SubcircuitLibrary/74LS93A/74LS93A.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Thu Jan 16 13:49:09 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U14-Pad2_ Net-_U14-Pad2_ Net-_U1-Pad3_ ? ? Net-_U2-Pad6_ Net-_U2-Pad7_ d_jkff
U3  Net-_U14-Pad2_ Net-_U14-Pad2_ Net-_U1-Pad4_ ? ? Net-_U3-Pad6_ Net-_U2-Pad7_ d_jkff
U5  Net-_U14-Pad2_ Net-_U14-Pad2_ Net-_U4-Pad6_ ? ? Net-_U10-Pad1_ Net-_U2-Pad7_ d_jkff
U6  Net-_U11-Pad3_ Net-_U11-Pad4_ Net-_U2-Pad7_ d_nand
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ Net-_U11-Pad4_ adc_bridge_2
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ adc_bridge_2
U7  Net-_U2-Pad6_ Net-_U13-Pad1_ d_inverter
U8  Net-_U3-Pad6_ Net-_U13-Pad2_ d_inverter
U9  Net-_U4-Pad6_ Net-_U13-Pad3_ d_inverter
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R1  Net-_R1-Pad1_ Net-_Q1-Pad2_ 1k
R5  Net-_R5-Pad1_ Net-_Q1-Pad1_ 100
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R2  Net-_R2-Pad1_ Net-_Q2-Pad2_ 1k
R6  Net-_R5-Pad1_ Net-_Q2-Pad1_ 100
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R3  Net-_R3-Pad1_ Net-_Q3-Pad2_ 1k
R7  Net-_R5-Pad1_ Net-_Q3-Pad1_ 100
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q1-Pad3_ eSim_NPN
R4  Net-_R4-Pad1_ Net-_Q4-Pad2_ 1k
R8  Net-_R5-Pad1_ Net-_Q4-Pad1_ 100
U12  Net-_U1-Pad2_ Net-_U11-Pad2_ Net-_U11-Pad1_ ? Net-_R5-Pad1_ ? ? Net-_Q3-Pad1_ Net-_Q2-Pad1_ Net-_Q1-Pad3_ Net-_Q4-Pad1_ Net-_Q1-Pad1_ ? Net-_U1-Pad1_ PORT
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ Net-_U10-Pad2_ Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_R3-Pad1_ Net-_R4-Pad1_ dac_bridge_4
U4  Net-_U14-Pad2_ Net-_U14-Pad2_ Net-_U3-Pad6_ ? ? Net-_U4-Pad6_ Net-_U2-Pad7_ d_jkff
v1  Net-_U14-Pad1_ GND 5
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ adc_bridge_1

.end
